# Keil uVision project MZ-SYS.uvprojx, settings and files
target MZ-SYS (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MZ-SYS +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Output/MZ-SYS.bin ./Output/MZ-SYS.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Drivers\Lib;.\Drivers\Lib\inc;.\MZ_Sys;.\Drivers;.\MZ_Sys\Pages;.\FatFS;.\uCos;.\uCos\Cpu;.\uCos\Ports;.\uCos\Lib;.\MZ_Sys\MZ_Gui;.\MZ_Sys\MZ_Heap;.\Drivers\UsbLib\inc;.\Drivers\Usb\inc;.\MZ_Sys\CtrlObj;.\MZ_Sys\MZ_Find;.\MZ_Sys\MZ_Find\MZ_Crypto;.\MZ_Sys\MZ_Find\MZ_USB;.\MZ_Sys\MZ_Find\MZ_Search;.\MZ_Sys\MZ_Find\MZ_Pinyin;.\MZ_Sys\MZ_Find\MZ_Config;.\MZ_Sys\MZ_Find\MZ_Irda;.\MZ_Sys\MZ_Find\MZ_Pic;.\Utilities;.\Pages;.\MZ_Sys\Tasks
  memory RVCT4: ROM 0x8002800 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: STM32F10x.s
  group Drivers
    ./Drivers/: Rtc.c Time.c Uart.c flash.c Delay.c wdg.c led.c spi.c spiFlash.c
  group uCos
    ./uCos/: os_core.c os_mutex.c os_sem.c os_task.c os_time.c os_flag.c os_mbox.c os_mem.c os_q.c os_tmr.c
    ./uCos/Cpu/: cpu_c.c cpu_a.asm
    ./uCos/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group System
    ./: main.c
    ./MZ_Sys/: SystemInit.c Dispatcher.c DisplayProtocol.c
    ./MZ_Sys/Tasks/: WirelessApp.c Wlan4GApp.c
  group Lib
    ./Drivers/Lib/: stm32f10x_it.c core_cm3.c
    ./Drivers/Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group UserLib
    ./UserLib/: MZWireless_131.lib MZWlan4G_131.lib Os_Wrap.c MZAirIap_132_240K.lib
  group Utilities
    ./Utilities/: DisplayPara.c ParaSettingLib.c FoodlineControl.c StateMachine.c
  group Pages
    ./Pages/: Page2PathConfig.c Page1FlinePathConfig.c Page3FlineDevice.c Page5Revise.c Page6ReadPathConfig.c Page7ControlFline.c Page8SwitchValve.c Page9SwitchValveConfig.c Page10TowersOut.c Page11TowersOutConfig.c Page12S1S2Control.c Page13LinkConfig .c Page14W1Control.c Page15W2Control.c Page16E1E2Control.c Page17C1Control.c Page18C2Control.c Page19N1Control.c Page20N2Control.c
target EnvironmentController_Release (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: EnvironmentController_Release +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Output/EnvironmentController_Release.bin ./Output/EnvironmentController_Release.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: as above
  memory RVCT4: ROM 0x8002800 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.1.1
